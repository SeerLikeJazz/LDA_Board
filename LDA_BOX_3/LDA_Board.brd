# Repository SeerLikeJazz/LDA_Board

## EAGLE design LDA_BOX_3/LDA_Board.brd

Parts:
B-1: SIDE-BUTTON
BATTERY-1: BATTERY
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27: 15pf; C0402
D2, D3, D4, D5, D6, D11: BLUE-0402; LED-0402
D8: SS14; SMA
ESP8266: 6p-2.54; H6-2.54
HC05-1: BLUETOOTH
IC1: STM32F407ZET; LQFP144
LED2-1: DOUBLE_LED; LED2-SMD-1010
MCP73831-1: MCP73831; SOT23-5
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R19, R25, R26: 0R; R0402
RT9013-1: RT9013; SOT23-5
SW3P-2: LD-CCB-001; SW3-2.54-9.0X3.5X3.5+2.0MM
SW-1: SWITCH-3P
USART1: 3p-2.54; H3-2.54
USB2: ZX62-B-5PA; MICRO-USB5+6P-SMD-0.65-AB
W25Q128: W25Q128; SOP08
Y1: 8MHZ; X4-SMD-3.2X2.5X0.7MM

Connections:
+3.7V: C12.2, RT9013-1.1 (VIN), RT9013-1.3 (EN), SW-1.P$2 (COM)
+3V3: C11.1, C13.2, C14.2, C15.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, ESP8266.6, HC05-1.P$12 (VCC), IC1.17 (VDD), IC1.30 (VDD), IC1.39 (VDD), IC1.52 (VDD), IC1.62 (VDD), IC1.72 (VDD), IC1.84 (VDD), IC1.95 (VDD), IC1.108 (VDD), IC1.121 (VDD), IC1.131 (VDD), IC1.144 (VDD), R1.1, R2.1, R4.2, R9.1, R10.1, R11.1, R12.1, R13.1, R15.1, RT9013-1.5 (VOUT), W25Q128.3 (WP#), W25Q128.7 (HOLD), W25Q128.8 (VCC)
+5V: C10.2, D8.C, LED2-1.1, MCP73831-1.4 (VDD)
BATTERY: BATTERY-1.P$1 (+), C9.2, MCP73831-1.3 (VBAT), SW-1.P$3 (A)
BT_RESET: HC05-1.P$26 (PIO3), IC1.65 (PE12), R25.1
CLK: IC1.109 (PA14), R7.2
GBC_KEY: ESP8266.2, IC1.74 (PB13)
GBC_LED: ESP8266.1, IC1.73 (PB12)
GND: B-1.P$1 (2), BATTERY-1.P$2 (-), C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.1, C14.1, C15.2, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, D11.-, ESP8266.5, HC05-1.P$13 (GND), HC05-1.P$22 (CON), IC1.16 (VSS), IC1.31 (VSSA), IC1.38 (VSS), IC1.51 (VSS), IC1.61 (VSS), IC1.83 (VSS), IC1.94 (VSS), IC1.107 (VSS), IC1.120 (VSS), IC1.130 (VSS), LED2-1.3, MCP73831-1.2 (VSS), R5.1, R6.1, R14.2, R25.2, RT9013-1.2 (GND), SW3P-2.1 (A), USART1.1, USB2.5 (GND), USB2.P1 (SHIELD), USB2.P2 (SHIELD), USB2.P3 (SHIELD), USB2.P4 (SHIELD), USB2.P5 (SHIELD), USB2.P6 (SHIELD), W25Q128.4 (GND)
KEY1: IC1.35 (PA1), SW3P-2.2 (B)
LED1: D2.-, IC1.21 (PF9)
LED2: D3.-, IC1.22 (PF10)
LED3: D4.-, IC1.27 (PC1)
LED4: D5.-, IC1.28 (PC2)
LED5: D6.-, IC1.29 (PC3)
unnamed: IC1.138 (BOOT0), R5.2
unnamed: C2.1, IC1.71 (VCAP1)
unnamed: C3.1, IC1.106 (VCAP2)
unnamed: IC1.48 (PB2), R6.2
unnamed: C1.1, C4.2, C5.2, IC1.32 (VREF+), IC1.33 (VDDA), R1.2
unnamed: MCP73831-1.1 (STAT), R8.2
unnamed: IC1.143 (PDR_ON), R2.2
unnamed: D2.+, R9.2
unnamed: D3.+, R10.2
unnamed: MCP73831-1.5 (PROG), R14.1
unnamed: D4.+, R11.2
unnamed: D5.+, R12.2
unnamed: D6.+, R13.2
unnamed: LED2-1.4, R8.1
unnamed: LED2-1.2, R15.2
unnamed: HC05-1.P$24 (PIO1), R26.1
unnamed: D11.+, R26.2
OSC_IN: C6.2, IC1.23 (OSC_IN), R3.2, Y1.1 (2)
OSC_OUT: C7.2, IC1.24 (OSC_OUT), R3.1, Y1.3 (4)
RESET: B-1.P$2 (1), C8.2, IC1.25 (NRST), R4.1
RX1: IC1.102 (PA10), USART1.2
RX2: ESP8266.4, IC1.37 (PA3)
RX3: HC05-1.P$1 (TXD), IC1.70 (PB11)
SPI1_CLK: IC1.41 (PA5), W25Q128.6 (CLK)
SPI1_CS: IC1.40 (PA4), W25Q128.1 (CS)
SPI1_MISO: IC1.42 (PA6), W25Q128.2 (SO)
SPI1_MOSI: IC1.43 (PA7), W25Q128.5 (SI)
SWD: IC1.105 (PA13), R19.2
TX1: IC1.101 (PA9), USART1.3
TX2: ESP8266.3, IC1.36 (PA2)
TX3: HC05-1.P$2 (RXD), IC1.69 (PB10)
USB_D+: R19.1, USB2.3 (D+)
USB_D-: R7.1, USB2.2 (D-)
VBAT: IC1.6 (VBAT)
VBUS: D8.A, USB2.1 (VBUS)

Notes on the sheet:
1、milling需要注意
2、flash封装需要修改
3、双色led

Board: 4 copper layers, 79.5 x 54.5 mm, 65 parts (1 on the bottom side), 49 nets.

## Commit log

2017-09-19 第一版PCB，用于验证
2017-11-10 3D打印了盒子
2017-12-14 第二版盒子，器件在一端
2017-12-16 第三版盒子，丝印加了logo
